# Keil uVision project quadricoptere.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32L152RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: quadricoptere
  c flags: Optim=4 oTime=1
  c define: __heap_base__=Image$$RW_IRAM1$$ZI$$Limit __heap_end__=Image$$RW_IRAM2$$Base
  c include: ..\Projet_propre;.\OS\kernel\include;.\OS\ports\common\ARMCMx;.\OS\ports\common\ARMCMx\CMSIS\include;.\OS\ports\RVCT\ARMCMx;.\OS\ports\RVCT\ARMCMx\STM32L1xx;.\OS\hal\include;.\OS\hal\platforms\STM32;.\OS\hal\platforms\STM32\GPIOv2;.\OS\hal\platforms\STM32\TIMv1;.\OS\hal\platforms\STM32\I2Cv1;.\OS\hal\platforms\STM32\USARTv1;.\OS\hal\platforms\STM32L1xx;.\conf
  asm misc: --cpreproc
  asm include: ..\Projet_propre;.\conf;.\OS\ports\RVCT\ARMCMx\STM32L1xx
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  memory RVCT10: RAM 0x20020000 size 0x1
  group main
    ./: main.c motor.c gyro.c alti.c battery.c xbee.c
  group conf
    ./conf/: board.c board.h chconf.h halconf.h mcuconf.h
  group os
    ./OS/kernel/src/: chlists.c chschd.c chsem.c chsys.c chthreads.c chvt.c chcond.c chdebug.c chdynamic.c chevents.c chheap.c chmboxes.c chmemcore.c chmempools.c chmsg.c chmtx.c chqueues.c chregistry.c
  group hal
    ./OS/hal/src/: hal.c pal.c pwm.c i2c.c serial.c icu.c
  group platform
    ./OS/hal/platforms/STM32/GPIOv2/: pal_lld.c
    ./OS/hal/platforms/STM32L1xx/: hal_lld.c stm32_dma.c
    ./OS/hal/platforms/STM32/TIMv1/: pwm_lld.c icu_lld.c
    ./OS/hal/platforms/STM32/I2Cv1/: i2c_lld.c
    ./OS/hal/platforms/STM32/USARTv1/: serial_lld.c
  group port
    ./OS/ports/RVCT/ARMCMx/: chcore.c chcore_v7m.c chcoreasm_v7m.s cstartup.s
    ./OS/ports/common/ARMCMx/: nvic.c
    ./OS/ports/RVCT/ARMCMx/STM32L1xx/: vectors.s
